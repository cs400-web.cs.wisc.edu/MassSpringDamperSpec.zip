classdef MassSpringDamperApp < matlab.apps.AppBase

    % Properties that correspond to app components
    properties (Access = public)
        GUI                             matlab.ui.Figure
        GridLayout0                     matlab.ui.container.GridLayout
        GridLayout11                    matlab.ui.container.GridLayout
        Panel112                        matlab.ui.container.Panel
        GridLayout112                   matlab.ui.container.GridLayout
        StiffnessNmSpinnerLabel         matlab.ui.control.Label
        StiffnessUIC                    matlab.ui.control.Spinner
        MassKgLabel                     matlab.ui.control.Label
        MassUIC                         matlab.ui.control.Spinner
        DampingNmsSpinnerLabel          matlab.ui.control.Label
        DampingUIC                      matlab.ui.control.Spinner
        InitialPositionmEditFieldLabel  matlab.ui.control.Label
        X0UIC                           matlab.ui.control.NumericEditField
        Panel                           matlab.ui.container.Panel
        GridLayout115                   matlab.ui.container.GridLayout
        StopTimesSpinnerLabel           matlab.ui.control.Label
        StopTimeUIC                     matlab.ui.control.Spinner
        SimulateButton                  matlab.ui.control.Button
        InputForceShapeUIC              matlab.ui.control.DropDown
        InputForceMagnitudeUIC          matlab.ui.control.Spinner
        InputForceLabel                 matlab.ui.control.Label
        Image                           matlab.ui.control.Image
        GridLayout12                    matlab.ui.container.GridLayout
        PositionUIAxes                  matlab.ui.control.UIAxes
        VelocityUIAxes                  matlab.ui.control.UIAxes
        InputForceUIAxes                matlab.ui.control.UIAxes
    end

    
    methods (Access = private)
        
        function extInp = externalInput(app)
            Tstop = app.StopTimeUIC.Value;
            T0 = Tstop/20;
            F = app.InputForceMagnitudeUIC.Value;
            
            switch (app.InputForceShapeUIC.Value)
                case 'Gate'
                    tv = [0 T0 T0 2*T0 2*T0 Tstop]';
                    uv = [0  0  F    F    0     0]';
                case 'Step'
                    tv = [0 T0 T0 Tstop]';
                    uv = [0  0  F     F]';
                case 'Ramp'
                    tv = [0 T0 Tstop]';
                    uv = [0  0     F]';
                case 'Bumpy'
                    tv = [0 linspace(T0,Tstop-T0,10) Tstop]';
                    uv = [0 2*F*(rand(1,10)-0.5) 0]';
                otherwise
                    error('invalid input signal type');
            end
            plot(app.InputForceUIAxes, tv, uv, 'Marker','.');
            umin = min(uv); umax = max(uv); urng = 0.1*(umax-umin);
            app.InputForceUIAxes.YLim = [umin-urng umax+urng];
            extInp = [tv uv];
        end % externalInput
        
        function toggleUIC(app, state, label)
            % toggle the state of the uicontrols in the app
            uics = findall(app.GUI);
            for idx = 1:length(uics)
               uic = uics(idx);
               if isprop(uic,'Enable')
                   uic.Enable = state;
               end
            end
            % update the simulate button text
            app.SimulateButton.Text = label;
            drawnow; % flush the ui events queue
        end % toggleUIC
    end

    % Callbacks that handle component events
    methods (Access = private)

        % Code that executes after component creation
        function startupFcn(app)
            % load simulink to pay the one time cost of loading libraries
            % % during app startup.
            start_simulink;
        end

        % Button pushed function: SimulateButton
        function SimulateButtonPushed(app, event)
            try
                app.toggleUIC('off', 'Simulating ...');

                % create the simulation input
                simInp = Simulink.SimulationInput('MassSpringDamperModel');

                % set the parameters for this run
                simInp = simInp.setVariable('k',app.StiffnessUIC.Value);
                simInp = simInp.setVariable('m',app.MassUIC.Value);
                simInp = simInp.setVariable('b',app.DampingUIC.Value);
                simInp = simInp.setVariable('x0',app.X0UIC.Value);
                
                % set the model parameters for this run
                stopTimeStr = num2str(app.StopTimeUIC.Value);
                simInp = simInp.setModelParameter('StopTime', stopTimeStr);

                % set the external input for this run
                simInp.ExternalInput = app.externalInput();

                % configure simInp for deployment
                simInp = simulink.compiler.configureForDeployment(simInp);
                % DEBUG TIP: Comment out the line above for faster debug
                % iterations when runnng this app in the MATLAB desktop.
                
                % run
                simOut = sim(simInp);
                
                % extract and plot the results
                t = simOut.y.time;
                yp = simOut.y.signals(1).values;
                yv = simOut.y.signals(2).values;
                plot(app.PositionUIAxes, t, yp);
                plot(app.VelocityUIAxes, t, yv);
            catch ME
                uialert(app.GUI, ME.getReport('basic'), 'Error');    
            end
            app.toggleUIC('on', 'Simulate');
        end

        % Image clicked function: Image
        function ImageClicked(app, event)
            if isequal(app.Image.ImageSource,'MassSpringDamper.png')
                app.Image.ImageSource = 'MassSpringDamperModel.svg';
            else
                if ~(ismcc || isdeployed)
                    disp('Opening MassSpringDamperModel ..');
                    open_system('MassSpringDamperModel.slx');
                end
                app.Image.ImageSource = 'MassSpringDamper.png';
            end
        end
    end

    % Component initialization
    methods (Access = private)

        % Create UIFigure and components
        function createComponents(app)
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            app.GUI = uifigure('Visible', 'off');
            app.GUI.Name = 'Mass Spring Damper';
            app.GridLayout0 = uigridlayout(app.GUI);
            app.GridLayout11 = uigridlayout(app.GridLayout0);
            app.Panel112 = uipanel(app.GridLayout11);
            app.GridLayout112 = uigridlayout(app.Panel112);
            app.StiffnessNmSpinnerLabel = uilabel(app.GridLayout112);
            app.StiffnessNmSpinnerLabel.Text = 'Stiffness (N/m)';
            app.StiffnessUIC = uispinner(app.GridLayout112);
            app.StiffnessUIC.Limits = [0 Inf];
            app.StiffnessUIC.Value = 128;
            app.MassKgLabel = uilabel(app.GridLayout112);
            app.MassKgLabel.Text = 'Mass (Kg)';
            app.MassUIC = uispinner(app.GridLayout112);
            app.MassUIC.Value = 2;
            app.DampingNmsSpinnerLabel = uilabel(app.GridLayout112);
            app.DampingNmsSpinnerLabel.Text = 'Damping (N/m/s)';
            app.DampingUIC = uispinner(app.GridLayout112);
            app.DampingUIC.Limits = [0 Inf];
            app.DampingUIC.Value = 3;
            app.InitialPositionmEditFieldLabel = uilabel(app.GridLayout112);
            app.InitialPositionmEditFieldLabel.Text = 'Initial Position (m)';
            app.X0UIC = uieditfield(app.GridLayout112, 'numeric');
            app.Panel = uipanel(app.GridLayout11);
            app.GridLayout115 = uigridlayout(app.Panel);
            app.StopTimesSpinnerLabel = uilabel(app.GridLayout115);
            app.StopTimesSpinnerLabel.Text = 'Stop Time (s)';
            app.StopTimeUIC = uispinner(app.GridLayout115);
            app.StopTimeUIC.Step = 5;
            app.StopTimeUIC.Limits = [0 Inf];
            app.StopTimeUIC.Value = 20;
            app.SimulateButton = uibutton(app.GridLayout115, 'push');
            app.SimulateButton.ButtonPushedFcn = createCallbackFcn(app, @SimulateButtonPushed, true);
            app.SimulateButton.Text = 'Simulate';
            app.InputForceShapeUIC = uidropdown(app.GridLayout115);
            app.InputForceShapeUIC.Items = {'Gate', 'Step', 'Ramp', 'Bumpy'};
            app.InputForceShapeUIC.Value = 'Gate';
            app.InputForceMagnitudeUIC = uispinner(app.GridLayout115);
            app.InputForceMagnitudeUIC.Step = 5;
            app.InputForceMagnitudeUIC.Value = 10;
            app.InputForceLabel = uilabel(app.GridLayout115);
            app.InputForceLabel.Text = 'Input Force (N)';
            app.Image = uiimage(app.GridLayout11);
            app.Image.ImageClickedFcn = createCallbackFcn(app, @ImageClicked, true);
            app.Image.ImageSource = 'MassSpringDamperModel.svg';
            app.GridLayout12 = uigridlayout(app.GridLayout0);
            app.PositionUIAxes = uiaxes(app.GridLayout12);
            title(app.PositionUIAxes, '')
            xlabel(app.PositionUIAxes, '')
            ylabel(app.PositionUIAxes, 'Position')
            app.VelocityUIAxes = uiaxes(app.GridLayout12);
            title(app.VelocityUIAxes, '')
            xlabel(app.VelocityUIAxes, '')
            ylabel(app.VelocityUIAxes, 'Velocity')
            app.InputForceUIAxes = uiaxes(app.GridLayout12);
            title(app.InputForceUIAxes, '')
            xlabel(app.InputForceUIAxes, '')
            ylabel(app.InputForceUIAxes, 'Input Force')
            % Show the figure after all components are created
            app.GUI.Visible = 'on';
        end
    end

    % App creation and deletion
    methods (Access = public)

        % Construct app
        function app = MassSpringDamperApp

            % Create UIFigure and components
            createComponents(app)

            % Register the app with App Designer
            registerApp(app, app.GUI)

            % Execute the startup function
            runStartupFcn(app, @startupFcn)

            if nargout == 0
                clear app
            end
        end

        % Code that executes before app deletion
        function delete(app)

            % Delete UIFigure when app is deleted
            delete(app.GUI)
        end
    end
end